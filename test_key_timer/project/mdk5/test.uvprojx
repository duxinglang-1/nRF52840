# Keil uVision project test.uvprojx, settings and files
target IK-52840DK (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(64000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: nrf52840_qiaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10056 FLOAT_ABI_HARD CONFIG_GPIO_AS_PINRESET NRF52840_XXAA BSP_DEFINES_ONLY _STACK_SIZE=8192 _HEAP_SIZE=8192
  c misc: --reduce_paths
  c include: ..\config;..\..\components\boards;..\..\components\drivers_nrf\nrf_soc_nosd;..\..\components\libraries\delay;..\..\components\libraries\util;..\..\components\libraries\strerror;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\memobj;..\..\components\libraries\balloc;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\fifo;..\..\components\libraries\uart;..\..\modules\nrfx;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\modules\nrfx\drivers\include;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\app\lcd;..\..\app\datetime;..\..\app\font;..\..\app\image;..\..\components\libraries\button;..\..\components\libraries\timer;..\..\components\libraries\gpiote
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../../app/: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../components/boards/: boards.c
  group nRF_Libraries
    ../../components/libraries/util/: app_error.c app_util_platform.c app_error_handler_keil.c app_error_weak.c nrf_assert.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/timer/: app_timer.c
    ../../components/libraries/gpiote/: app_gpiote.c
  group APP
    ../../app/lcd/: lcd.c
    ../../app/datetime/: datetime.c
    ../../app/font/: font.c
    ../../app/image/: img.c
    ../../app/key/: key.c
  group nRF_Drivers
    ../../modules/nrfx/hal/: nrf_nvmc.c
    ../../integration/nrfx/legacy/: nrf_drv_uart.c nrf_drv_clock.c
    ../../modules/nrfx/drivers/src/: nrfx_timer.c nrfx_uart.c nrfx_uarte.c nrfx_gpiote.c nrfx_clock.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
